Commit message: update office environment, need to clean up

File: roboverse/assets/room_descriptions/urdf/room_v0.urdf (robot description, URDF)
Before this commit: robot room, 18 links, 17 joints
Links:
- link room_base: mass None -> 0
